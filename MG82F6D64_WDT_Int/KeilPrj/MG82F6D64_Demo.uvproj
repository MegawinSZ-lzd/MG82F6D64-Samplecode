# Keil uVision project MG82F6D64_Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: MG82F6D64 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0xEFF) CLOCK(25000000)
  output: MG82F6D64_DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../code/: MAIN.C
